# Keil uVision project project.uvproj, settings and files
target tr-thread (ARM-ADS)
  device: STM32F103VD STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x805FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: project +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\apps;..\drivers;..\rt-thread-2.0.1\include;..\rt-thread-2.0.1\components\finsh;..\third_part\STM32F10x_StdPeriph_Driver\inc;..\rt-thread-2.0.1\libcpu\arm\common;..\rt-thread-2.0.1\libcpu\arm\cortex-m3;..\third_part\CMSIS\CM3\CoreSupport;..\third_part\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\rt-thread-2.0.1\components\init;..\rt-thread-2.0.1\components\drivers\include;..\rt-thread-2.0.1\components\CMSIS\Include;..\rt-thread-2.0.1\components\net\lwip-1.4.1\src;..\rt-thread-2.0.1\components\net\lwip-1.4.1\src\include;..\rt-thread-2.0.1\components\net\lwip-1.4.1\src\include\ipv4;..\rt-thread-2.0.1\components\net\lwip-1.4.1\src\netif;..\rt-thread-2.0.1\components\net\lwip-1.4.1\src\arch\include;..\rt-thread-2.0.1\components\drivers\include;..\enc28j60
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*   --keep __rt_init*
  group Startup
    ../apps/: application.c startup.c udpserver.c
  group Driver
    ../drivers/: board.c led.c stm32f10x_it.c usart.c drv_systick.c platform.c rt_stm32f10x_spi.c
    ../rt-thread-2.0.1/components/drivers/serial/: serial.c
    ../rt-thread-2.0.1/components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c workqueue.c portal.c
    ../rt-thread-2.0.1/components/drivers/spi/: spi_core.c spi_dev.c
    ../enc28j60/: enc28j60.c
  group CORTEX-M3
    ../rt-thread-2.0.1/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../rt-thread-2.0.1/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group Stm32_StdPeriph
    ../third_part/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../third_part/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../third_part/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group kernel
    ../rt-thread-2.0.1/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group Finsh
    ../rt-thread-2.0.1/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c shell.c symbol.c
  group Components
    ../rt-thread-2.0.1/components/init/: components.c
  group LwIP
    ../rt-thread-2.0.1/components/net/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../rt-thread-2.0.1/components/net/lwip-1.4.1/src/arch/: sys_arch.c
    ../rt-thread-2.0.1/components/net/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../rt-thread-2.0.1/components/net/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../rt-thread-2.0.1/components/net/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
